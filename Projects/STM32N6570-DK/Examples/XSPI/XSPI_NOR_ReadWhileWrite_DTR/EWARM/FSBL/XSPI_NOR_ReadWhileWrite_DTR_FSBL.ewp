# IAR project XSPI_NOR_ReadWhileWrite_DTR_FSBL.ewp, settings and files
configuration XSPI_NOR_ReadWhileWrite_DTR_FSBL (ARM, debug)
  General.OGChipSelectEditMenu: STM32N6570-DK ST STM32N6570-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32N657xx
  ICCARM.CCIncludePath2: ../../FSBL/Inc; ../../../../../../../Drivers/BSP/STM32N6570-DK; C:/Users/frq09519/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0RC1/Drivers/STM32N6xx_HAL_Driver/Inc; C:/Users/frq09519/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0RC1/Drivers/CMSIS/Device/ST/STM32N6xx/Include; C:/Users/frq09519/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0RC1/Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; C:/Users/frq09519/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0RC1/Middlewares/ST/STM32_ExtMem_Manager; C:/Users/frq09519/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0RC1/Middlewares/ST/STM32_ExtMem_Manager/boot; C:/Users/frq09519/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0RC1/Middlewares/ST/STM32_ExtMem_Manager/sal; C:/Users/frq09519/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0RC1/Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp; C:/Users/frq09519/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0RC1/Middlewares/ST/STM32_ExtMem_Manager/psram; C:/Users/frq09519/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0RC1/Middlewares/ST/STM32_ExtMem_Manager/sdcard; C:/Users/frq09519/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0RC1/Middlewares/ST/STM32_ExtMem_Manager/user; C:/Users/frq09519/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0RC1/Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../Binary/XSPI_NOR_ReadWhileWrite_DTR_FSBL.bin
  ILINK.IlinkOutputFile: XSPI_NOR_ReadWhileWrite_DTR_FSBL.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram2_fsbl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32n657xx_fsbl.s
  group Application/User/FSBL
    ../../FSBL/Src/: main.c extmem_manager.c stm32n6xx_it.c stm32n6xx_hal_msp.c
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32N6570-DK
    ../../../../../../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c
  group Drivers/CMSIS
    ../../FSBL/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    C:/Users/frq09519/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0RC1/Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal_bsec.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_cortex.c stm32n6xx_hal.c stm32n6xx_hal_exti.c stm32n6xx_hal_xspi.c
  group Middlewares/STM32_ExtMem_Manager
    C:/Users/frq09519/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0RC1/Middlewares/ST/STM32_ExtMem_Manager/: stm32_extmem.c
    C:/Users/frq09519/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0RC1/Middlewares/ST/STM32_ExtMem_Manager/boot/: stm32_boot_xip.c
    C:/Users/frq09519/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0RC1/Middlewares/ST/STM32_ExtMem_Manager/sal/: stm32_sal_xspi.c stm32_sal_sd.c
    C:/Users/frq09519/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0RC1/Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp/: stm32_sfdp_data.c stm32_sfdp_driver.c
    C:/Users/frq09519/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0RC1/Middlewares/ST/STM32_ExtMem_Manager/psram/: stm32_psram_driver.c
    C:/Users/frq09519/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0RC1/Middlewares/ST/STM32_ExtMem_Manager/sdcard/: stm32_sdcard_driver.c
    C:/Users/frq09519/STM32Cube/Repository/STM32Cube_FW_N6_V1.3.0RC1/Middlewares/ST/STM32_ExtMem_Manager/user/: stm32_user_driver.c
